# Keil uVision project LAB6.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LAB6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\Charles Tejano\Documents\STM32Cube_FW_F4_V1.28.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;C:\Keil\STM32Cube_FW_F4_V1.28.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: LCD.c LCD.h ultrasonic.c ultrasonic.h MOTOR.c MOTOR.h main.c RPG.c RPG.h lis3dsh.c lis3dsh.h
    C:/Keil/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    C:/Keil/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
software components: CMSIS-Compiler:CORE 1.2.0, CMSIS:CORE 6.2.0
